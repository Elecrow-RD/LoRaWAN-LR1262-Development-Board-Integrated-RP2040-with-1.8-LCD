# Repository Elecrow-RD/LoRaWAN-LR1262-Development-Board-Integrated-RP2040-with-1.8-LCD

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | latest |

### 3, product information

#### Display Module Specifications

**GPIO Pin Definition**

| RP2040 | LR1262 Development Board                 |        |                                         |
| ------ | ---------------------------------------- | ------ | --------------------------------------- |
| GPIO0  | LR1262-RXD                               | GPIO15 | GPIO15/ Crowtail-D1                     |
| GPIO1  | LR1262-TXD                               | GPIO16 | LCD-DC                                  |
| GPIO2  | GPIO2                                    | GPIO17 | LCD-CS                                  |
| GPIO3  | GPIO3                                    | GPIO18 | LCD-SCK                                 |
| GPIO4  | Crowtail-UART1-TXD                       | GPIO19 | LCD-DIN                                 |
| GPIO5  | Crowtail-UART1-RXD                       | GPIO20 | I2C0-SDA0/Crowtail-I2C-SDA/PCA9555-SDA  |
| GPIO6  | GPIO6                                    | GPIO21 | I2C0-SCL0/Crowtail-I2C-SCL/ PCA9555-SCL |
| GPIO7  | GPIO7                                    | GPIO22 | LCD-RST                                 |
| GPIO8  | GPIO8/UART1-TX1/Crowtail-UART1-TX1/485TX | GPIO23 | LCD-BLK                                 |
| GPIO9  | GPIO9/UART1-RX1Crowtail-UART1-RX1/485RX  | GPIO24 | 485-EN                                  |
| GPIO10 | GPIO10/SPI1-SCK                          | GPIO25 | DATA                                    |
| GPIO11 | GPIO11/SPI1-MOSI                         | GPIO26 | A0/ Crowtail-A0                         |
| GPIO12 | GPIO12/SPI1-MISO                         | GPIO27 | A1/ Crowtail-A1                         |
| GPIO13 | GPIO13/SPI1-CS                           | GPIO28 | BUZZER                                  |
| GPIO14 | GPIO14/ Crowtail-D0                      | GPIO29 | ADC-KEY                                 |

## Feature

- Uses RP2040 as the main controller, with two 32-bit ARM Cortex M0+ processor cores (dual-core) ,and provides more powerful performance
- Integrates the LR1262 module supports the 868/915MHz frequency band and AT command control
- Abundant external interface resources, compatible with Crowtail series modules and other commonly interface modules on the market
- Integrates commonly used functionslike buzzer, LED light, LCD display and custom button, making it more concise and convenient when creating projects
- Onboard 1.8-inch 128*160 SPI-TFT-LCD, ST7735S driver chip
- Compatible with Arduino/Micropython, easy to carry out different projects.

## Specification

| Main Chip                      | Raspberry Pi chip RP2040, built-in 264KB SRAM, onboard 4MB Flash |
| ------------------------------ | ------------------------------------------------------------ |
| Processor                      | Dual Core Arm Cortex-M0+ @ 133MHz                            |
| LR1262 Supports frequency band | 803MHZ-930MHZ                                                |
| LR1262 Support Interface       | External antenna, SMA interface or IPEX first generation interface |
| LCD Display                    | Onboard 1.8-inch 128*160SPI-TFT-LCD                          |
| LCD Resolution                 | 128*160                                                      |
| LCD Driver                     | ST7735S (4-wire SPI)                                         |
| Development environment        | Arduino/Micropython                                          |
| Interface                      | 1x RS485 communication interface,8x 5V Crowtail interfaces (2x analog interfaces, 2xdigital interfaces, 2xUART interfaces, 2xIIC interfaces)12x 5V universal pin header IO interfaces14x 3.3V universal pin header IO interfaces1x 3.3V/5V switchable SPI interface1x 3.3V/5V switchable UART interface3x 3.3V/5V switchable IIC interfaces |
| Buttons and functions          | 1x passive buzzer,4x user-defined buttons,6x programmable LEDs |
| Working input voltage          | USB 5V-1A                                                    |
| Operating temperature          | -10°C ~ 65°C                                                 |
| Dimensions                     | 102mm(L)x76.5mm(W)                                           |

### 4,Quick Start

##### Arduino IDE starts

STEP1 Configure controller board&communication port
On top of the Arduino IDE, click “Tools>Board>” and select “*Rasperry Pi RP2040 Boards*” from the available options

STEP2 Select the COM port that indicates Rasperry Pi RP2040 Boards. Please note that the actual numbers after the “COM” word will vary from computer to computer, so they could be different from the ones shown in the figure.

### 6,Folder structure.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

## EAGLE design Eagle_SCH&PCB/Lora RA-08H_development_board_Eagle/ra-08h_development_board_V1.0-20230228.brd

Parts:
ANT1: SPARKFUN2_U.FL
ANT2: BU-SMA-H
C1, C2: 12PF; A_XBJ_0603
C3, C6, C15, C16: 2.2UF; A_XBJ_0603
C4, C5, C7, C8, C9, C10, C11, C12, C13, C14, C21, C24, C25, C26, C29, C30, C35, C36, C37: 100NF; A_XBJ_0603
C27, C28: 10UF; A_XBJ_0805
C31, C33: 22UF; A_XBJ_0805
C32, C34: 1UF; A_XBJ_0603
D1, D3: DISCRETE_007-LED0603; DISCRETE_D0603
D2: 1N4148; DISCRETE_DO-35-SMD
D4, D5, D6, D7, D8, D9: LED-3MM-NO_SILK; LED_3MM-NS
D11: SS14; DISCRETE_D2010
IC1: PCA9557-16P; TSSOP16
J1, J6, J7, J8, J9, J10, J11, J12: CONNECTER_TWIG_2.0; CONNECTER_2.0_1X4
J2, J4, J47, J49, J50: CONN_04PTH; 1X04
J3: A_XBJ_MLT-8530
J5, J26, J27: CONN_14; 1X14
J13: KF350_P3.5MM_3P
J14: KEVIN_TYPEC-3.0-16P-SMD; KEVIN_3.0TYPEC-SMD
J18, J19, J20: CONN_12; 1X12
J24, J25, J48: 455-1750-1-ND; 1X03
J46: CONN_06SILK_FEMALE_PTH; 1X06
K2, K3, K4, K5: CROWBO_KEY_2PIN_6.5X3.5; CROWBOT_-V1.2-20220713_CROWBOT-V1.1库_KEY_EN_2PIN_B/W
L1: 2.2UH 2A; CROWPI_POW_L773
LCD1: TFT1.8_SPI_14P_PCB; TFF1.8_SPI_14P_PCB
P1, P2, P3, P4, P7, P8, P9, P10, P11, P12, P13, P14: CROWPI_POW_PADPAD-1.0MM; CROWPI_POW_PAD-1.0MM
Q1, Q2, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31: 2N7002; DISCRETE_SOT23
Q3, Q4: S9013; DISCRETE_SOT23$1
R1, R7, R15, R22, R29: 10K; DISCRETE_R0603
R2, R6, R19, R23, R24, R25, R26, R28, R75, R76, R77, R78, R79, R80: 1K; DISCRETE_R0603
R3, R4, R8, R9, R14, R20, R30, R31, R32, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R71, R73, R74, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97, R98, R99, R100, R101, R102: 4.7K; DISCRETE_R0603
R5, R16, R17, R18: 0R; DISCRETE_R0603
R10, R11, R21: 22R; DISCRETE_R0603
R12, R13: 5.1K; DISCRETE_R0603
R27: 100R; DISCRETE_R0603
R33, R64: 240R 1%; DISCRETE_R0603
R34: 3K; DISCRETE_R0603
R45, R65: 470R 1%; DISCRETE_R0603
R72: 120R; DISCRETE_R0603
R81: 45.3K 1%; DISCRETE_R0603
R82: 10K 1%; DISCRETE_R0603
SW1, SW2, SW3: MYSMD_PB157_4.3X3; MYSMD_157SW
U1: RP2040_RP2040; RP2040_QFN-56
U2: SELF_W25Q128JV; SELF_SOIC-8-208MIL
U3: LD1117-3V3-SOT223; SOT223
U4: RA08H_MODULE_SMD_18P; RA08H_MODULE_SMT_18P
U5: MAX3485CSA; SO08
U6: HM3416H; CROWBOT_-V1.0-20220525_A_XBJ_SOT23-5
X1: 12MHZ_SMD3225; A_XBJ_SMD3225

Connections:
+1V1: C13.1, C14.1, C16.1, U1.23 (VDD_1V1), U1.45 (LDO_OUT), U1.50 (VDD_1V1)
+3V3: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C15.1, C24.1, C25.1, C26.2, C33.2, C34.1, C35.1, C36.1, IC1.16 (VCC), J26.1, J26.2, J26.3, J26.4, J26.5, J26.6, J26.7, J26.8, J26.9, J26.10, J26.11, J26.12, J26.13, J26.14, J48.1, L1.2, LCD1.4 (LED+), LCD1.10 (VCC), LCD1.11 (IOVCC), P13.P$1, Q1.1 (G), Q2.1 (G), Q5.1 (G), Q6.1 (G), Q7.1 (G), Q8.1 (G), Q9.1 (G), Q10.1 (G), Q11.1 (G), Q12.1 (G), Q13.1 (G), Q14.1 (G), Q15.1 (G), Q16.1 (G), Q17.1 (G), Q18.1 (G), Q24.1 (G), Q25.1 (G), Q26.1 (G), Q27.1 (G), Q28.1 (G), Q29.1 (G), Q30.1 (G), Q31.1 (G), R1.2, R3.2, R5.2, R7.2, R8.2, R14.2, R20.2, R23.2, R27.2, R31.2, R35.2, R36.2, R38.2, R40.2, R42.2, R43.2, R44.2, R46.2, R48.2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
+5V: C31.2, C32.1, D11.+, J1.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J14.A4, J14.A9, J14.B4, J14.B9, J19.1, J19.2, J19.3, J19.4, J19.5, J19.6, J19.7, J19.8, J19.9, J19.10, J19.11, J19.12, J48.3, P2.P$1, R4.2, R9.2, R30.2, R32.2, R37.2, R39.2, R41.2, R47.2, R49.2, R51.2, R53.2, R55.2, R57.2, R59.2, R61.2, R63.2, U6.1 (EN), U6.4 (VIN)
+VCC: J4.2, J46.2, J47.2, J48.2, J49.2, J50.2, R88.2, R90.2, R92.2, R94.2, R96.2, R98.2, R100.2, R102.2
A0: J5.14, R64.1, R65.2, U1.38 (GPIO26/ADC0)
A0_IN: J8.4, R64.2
A1: J5.13, R33.1, R45.2, U1.39 (GPIO27/ADC1)
A1_IN: J7.4, R33.2
A2: R28.2, U1.40 (GPIO28/ADC2)
A3: K2.1, R23.1, R24.2, U1.41 (GPIO29/ADC3)
A+: J13.2, R72.1, R74.2, U5.6 (A)
AVDD: C3.1, R5.1, U1.43 (ADC_VDD)
B-: J13.1, R72.2, R73.1, U5.7 (B)
BOOT: R6.2, SW2.2
D2: J5.12, Q5.2 (S), R36.1, U1.4 (GPIO2)
D2_H: J20.12, Q5.3 (D), R37.1
D3: J5.11, Q6.2 (S), R38.1, U1.5 (GPIO3)
D3_H: J20.11, Q6.3 (D), R39.1
D4/TX1: R17.2, U1.6 (GPIO4)
D5/RX1: R16.2, U1.7 (GPIO5)
D6/SDA1: J5.10, Q10.2 (S), R46.1, U1.8 (GPIO6)
D6/SDA1_H: J20.10, Q10.3 (D), R47.1
D7/SCL1: J5.9, Q15.2 (S), R56.1, U1.9 (GPIO7)
D7/SCL1_H: J20.9, Q15.3 (D), R57.1
D8/TX1: J5.8, J25.2, U1.11 (GPIO8)
D8/TX1_C: J25.3, Q7.2 (S), Q25.2 (S), R40.1, R89.1
D8/TX1_H: J10.3, J20.8, Q7.3 (D), R41.1
D8/TX1_P: J50.4, Q25.3 (D), R90.1
D9/RX1: J5.7, J24.2, U1.12 (GPIO9)
D9/RX1_C: J24.3, Q14.2 (S), Q28.2 (S), R54.1, R95.1
D9/RX1_H: J10.4, J20.7, Q14.3 (D), R55.1
D9/RX1_P: J50.3, Q28.3 (D), R96.1
D10/SCK: J5.6, Q11.2 (S), Q30.2 (S), R48.1, R99.1, U1.13 (GPIO10)
D10/SCK_H: J20.6, Q11.3 (D), R49.1
D10/SCK_P: J46.6, Q30.3 (D), R100.1
D11/MOSI: J5.5, Q12.2 (S), Q31.2 (S), R50.1, R101.1, U1.14 (GPIO11)
D11/MOSI_H: J20.5, Q12.3 (D), R51.1
D11/MOSI_P: J46.5, Q31.3 (D), R102.1
D12/MISO: J5.4, Q13.2 (S), Q26.2 (S), R52.1, R91.1, U1.15 (GPIO12)
D12/MISO_H: J20.4, Q13.3 (D), R53.1
D12/MISO_P: J46.4, Q26.3 (D), R92.1
D13/CS: J5.3, Q16.2 (S), Q29.2 (S), R58.1, R97.1, U1.16 (GPIO13)
D13/CS_H: J20.3, Q16.3 (D), R59.1
D13/CS_P: J46.3, Q29.3 (D), R98.1
D14: J5.2, Q17.2 (S), R60.1, U1.17 (GPIO14)
D14_H: J6.4, J20.2, Q17.3 (D), R61.1
D15: J5.1, Q18.2 (S), R62.1, U1.18 (GPIO15)
D15_H: J1.4, J20.1, Q18.3 (D), R63.1
D20/SDA0: IC1.2 (SDA), Q1.2 (S), Q27.2 (S), R3.1, R43.1, R93.1, U1.31 (GPIO20)
D20/SDA0_H: J11.3, J12.3, Q1.3 (D), R4.1
D20/SDA0_P: J4.3, J47.3, J49.3, Q27.3 (D), R94.1
D21/SCL0: IC1.1 (SCL), Q2.2 (S), Q24.2 (S), R8.1, R42.1, R87.1, U1.32 (GPIO21)
D21/SCL0_H: J11.4, J12.4, Q2.3 (D), R9.1
D21/SCL0_P: J4.4, J47.4, J49.4, Q24.3 (D), R88.1
D24: U1.36 (GPIO24), U5.2 (/RE), U5.3 (DE)
D25: R34.2, U1.37 (GPIO25)
D+: J14.A6, J14.B6, R11.1
D-: J14.A7, J14.B7, R10.1
GND: ANT1.P$1 (GND), ANT1.P$2 (GND), ANT2.2, ANT2.3 (2), ANT2.4 (2), ANT2.5 (2), C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C21.2, C24.2, C25.2, C26.1, C27.1, C28.1, C29.2, C30.2, C31.1, C32.2, C33.1, C34.2, C35.2, C36.2, C37.2, D1.-, D3.-, IC1.3 (A0), IC1.4 (A1), IC1.5 (A2), IC1.8 (VSS), J1.1, J2.1, J4.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.3, J14.A1, J14.A12, J14.B1, J14.B12, J14.P$1, J14.P$2, J14.P$3, J14.P$4, J18.1, J18.2, J18.3, J18.4, J18.5, J18.6, J18.7, J18.8, J18.9, J18.10, J18.11, J18.12, J27.1, J27.2, J27.3, J27.4, J27.5, J27.6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
GRE1: D5.K (C), IC1.11 (IO4)
GRE2: D9.K (C), IC1.14 (IO7)
IO2: SW3.1, U4.15 (IO2)
LCD_BLK: R19.1, U1.35 (GPIO23)
LCD_CS: LCD1.12 (CS), U1.28 (GPIO17)
LCD_DC: LCD1.7 (AO), U1.27 (GPIO16)
LCD_DIN: LCD1.8 (SDA), U1.30 (GPIO19)
LCD_RST: LCD1.6 (/RESET), U1.34 (GPIO22)
LCD_SCK: LCD1.9 (SCK), U1.29 (GPIO18)
LED-: LCD1.3 (LED-), R21.2
unnamed: C2.2, R2.1, X1.3 (XOUT)
unnamed: R2.2, U1.21 (XOUT)
unnamed: C1.1, U1.20 (XIN), X1.1 (XIN)
unnamed: R18.1, SW3.2
unnamed: C37.1, R15.2, U4.16 (RST)
unnamed: L1.1, U6.3 (SW)
unnamed: J14.B5, R12.1
unnamed: J14.A5, R13.2
unnamed: ANT1.P$3 (SIGNAL), ANT2.1, U4.18 (ANT)
unnamed: Q3.3 (C), R21.1
unnamed: R17.1, U4.10 (LPRXD)
unnamed: Q4.1 (B), R28.1, R29.2
unnamed: K3.1, R24.1, R25.2
unnamed: K4.1, R25.1, R26.2
unnamed: K5.1, R26.1
unnamed: D2.A (+), J3.2 (-), Q4.3 (C)
unnamed: D2.C (-), J3.1 (+), R27.1
unnamed: Q3.1 (B), R19.2, R22.1
unnamed: D1.+, R34.1
unnamed: D3.+, R35.1
unnamed: R81.2, R82.2, U6.5 (FB)
unnamed: D4.A, R75.1
unnamed: D5.A, R76.1
unnamed: D6.A, R77.1
unnamed: D7.A, R78.1
unnamed: D8.A, R79.1
unnamed: D9.A, R80.1
unnamed: IC1.15 (RESET/), R44.1
QSPI_CS: R6.1, R7.1, U1.56 (QSPI_!CS!), U2.1 (/CS)
QSPI_D0: U1.53 (QSPI_SD0), U2.5 (DI(IO0))
QSPI_D1: U1.55 (QSPI_SD1), U2.2 (DO(IO1))
QSPI_D2: U1.54 (QSPI_SD2), U2.3 (/WP(IO2))
QSPI_D3: U1.51 (QSPI_SD3), U2.7 (/HOLD/RESET(IO3))
QSPI_SCK: U1.52 (QSPI_SCLK), U2.6 (CLK)
RED1: D7.K (C), IC1.9 (IO2)
RED2: D4.K (C), IC1.12 (IO5)
RESET: C4.1, R1.1, SW1.2, U1.26 (RUN)
RF_3V3: C21.1, C28.2, C29.1, J2.2, P7.P$1, R15.1, R18.2, U3.2 (VOUT), U3.4 (TAB), U4.9 (VCC)
RF_+5V: C27.2, C30.1, D11.-, U3.3 (VIN)
RF_RX: J2.3, U4.12 (RXD0)
RF_SWCLK: P9.P$1, U4.7 (SWCLK)
RF_SWDIO: P8.P$1, U4.8 (SWDIO)
RF_TX: J2.4, R16.1, U4.11 (TXD)
RP_D0/TX0: Q8.2 (S), R20.1, U1.2 (GPIO0)
RP_D0/TX0_H: J9.3, Q8.3 (D), R30.1
RP_D1/RX0: Q9.2 (S), R31.1, U1.3 (GPIO1)
RP_D1/RX0_H: J9.4, Q9.3 (D), R32.1
RS_RX: J24.1, R71.1, U5.1 (RO)
RS_TX: J25.1, R14.1, U5.4 (DI)
SWCLK: P11.P$1, U1.24 (SWCLK)
SWDIO: P12.P$1, U1.25 (SWDIO)
USB_D+: P3.P$1, R11.2, U1.47 (USB_D+)
USB_D-: P4.P$1, R10.2, U1.46 (USB_D-)
YEL1: D6.K (C), IC1.10 (IO3)
YEL2: D8.K (C), IC1.13 (IO6)

Notes on the sheet:
Power Management
USB TO UART
RP2040_MCU MIN System
RA08-H Module
ADC KEY
Buzzer
TFT LCD 1.8 Inch SPI TO FPC
UART TO RS485
LED Indicator
5V电源，排针
Crowtail接口
排针，5V&3.3V跳线帽切换电源
排针，I2C接口
排针，UART接口
排针，SPI接口
3.3V电源，排针
LED Control
Vout=0.6*(R20/R21 +1)=3.3V
Boot:
RESET=0时，按下Boot-下载模式
Boot=1,正常运行
PCA9557 ADDRESS:
0011 000X
PWR
DATA
W25Q32
SP3485

Board: 2 copper layers, 102.0 x 76.5 mm, 218 parts (13 on the bottom side), 124 nets.

Other parts of the board:
U$26: ELECROW-NEW
